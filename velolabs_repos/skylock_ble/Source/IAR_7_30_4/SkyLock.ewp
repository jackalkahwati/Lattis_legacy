# IAR project SkyLock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NRF51; BLE_STACK_SUPPORT_REQD
  ICCARM.CCIncludePath2: ..\include\; ..\include\ARMFiles; ..\..\SDK_7_2_0\components\drivers_nrf\hal\; ..\..\SDK_7_2_0\components\softdevice\s110\headers\; ..\..\SDK_7_2_0\components\toolchain\; ..\..\SDK_7_2_0\components\softdevice\common\softdevice_handler\; ..\..\SDK_7_2_0\components\libraries\util\; ..\..\SDK_7_2_0\components\libraries\scheduler\; ..\..\SDK_7_2_0\components\libraries\timer\; ..\..\SDK_7_2_0\components\ble\common\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SkyLock.out
  ILINK.IlinkIcfFile: SkyLock.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: accelerometer.c ble_interface.c debuguart.c i2c.c magnet.c mfginterface.c motor.c nRF51822_vector.s skylock_softdevice.c startup.c timers.c touch_sensor.c utils.c
    ../../SDK_7_2_0/components/libraries/util/: app_error.c app_util_platform.c
    ../../SDK_7_2_0/components/libraries/scheduler/: app_scheduler.c
    ../../SDK_7_2_0/components/libraries/timer/: app_timer.c
    ../../SDK_7_2_0/components/ble/common/: ble_advdata.c ble_conn_params.c
